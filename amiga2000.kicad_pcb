# Repository rhaamo/kicad-amiga2000 (continued)

## KiCad design amiga2000.kicad_pcb (continued)

Schematic: parallel.kicad_sch

Parts:
C203, C300, C302, C303, C607, C909, C916: 0.1uF; C_Rect_L11.5mm_W2.6mm_P10.00mm_MKT
C259, C260, C261: 100pF; C_Rect_L11.5mm_W2.6mm_P10.00mm_MKT
C322, C323: 0.01uF; C_Rect_L11.5mm_W2.6mm_P10.00mm_MKT
C912: 470uF 16/25v; CP_Radial_D10.0mm_P5.00mm
CN300: KEYBOARD; DIN_5_KBD
CN301: DB25F; DSUB-25_Female_Horizontal_P2.77x2.84mm_EdgePinOffset7.70mm_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
CN302: DB23F; DSUB-23_Female_Horizontal_P2.77x2.84mm_EdgePinOffset7.70mm_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
CN303: Conn_02x17_Odd_Even; PinHeader_2x17_P2.54mm_Vertical
EMI300, EMI301, EMI302, EMI303, EMI304, EMI305, EMI306, EMI307, EMI308, EMI309, EMI310, EMI335, EMI336, EMI337, EMI338: 330pF (Type F 331); EMI_FILTER
EMI311, EMI312, EMI313, EMI314, EMI315, EMI316, EMI317, EMI318, EMI319, EMI320, EMI321: 100pF (Type F 101); EMI_FILTER
EMI322, EMI323, EMI324, EMI339, EMI340, EMI341: 100pF (Type C 101); EMI_FILTER
F3, F4: 4A; C_Rect_L11.5mm_W2.0mm_P10.00mm_MKT
FB301, FB302, FB303: Ferrite_Bead_Small; L_Axial_L7.0mm_D3.3mm_P10.16mm_Horizontal_Fastron_MICC
J3: ACCEL; PinHeader_1x02_P2.54mm_Vertical
J300: Conn_01x03_Male; PinHeader_1x03_P2.54mm_Vertical
J301: DF1:; PinHeader_2x01_P2.54mm_Vertical
Q301: 2N3904; TO-92_Inline
R201, R300, R309: 4.7k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R301, R602: 1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R310: 47 0.5W; R_Axial_DIN0411_L9.9mm_D3.6mm_P15.24mm_Horizontal
R914: 1 0.5W; R_Axial_DIN0411_L9.9mm_D3.6mm_P15.24mm_Horizontal
RP300: 10k; R_Array_SIP10
RP301: 1k; R_Array_SIP6
U102: GARY5719; DIP-48_W15.24mm_Socket
U108: 74LS74A; DIP-14_W7.62mm_Socket
U203: 74LS38; DIP-14_W7.62mm_Socket
U300: CIA8520; DIP-40_W15.24mm_Socket
U302: 74LS32; DIP-14_W7.62mm_Socket
U303: 74F08; DIP-14_W7.62mm_Socket
U607: 74LS08; DIP-14_W7.62mm_Socket
U900: 74F00; DIP-14_W7.62mm_Socket

Connections:
+5V_USER: R310.2; also elsewhere on the board
+12V: C322.1, F3.1; also elsewhere on the board
/parallel/_CHNG: CN303.2, EMI341.1, RP301.6 (R5), U300.4 (PA2)
/parallel/_DKRST: EMI312.1, U607.6
/parallel/_DKWDB: CN303.22, EMI315.1, U203.8
/parallel/_DKWEB: CN303.24, EMI314.1, U203.11
/parallel/_INUSE0: CN303.6, U900.3
/parallel/_IORST: C916.2, EMI300.1, U303.8
/parallel/_KBDATA: C261.1, CN300.2, FB303.1
/parallel/_MTROD: CN303.16, Q301.3 (C)
/parallel/_MTRX: EMI311.1, U203.3
/parallel/_RDY: CN303.34, EMI322.1, J301.2, RP301.2 (R1), U300.7 (PA5)
/parallel/_TRK0: CN303.26, EMI339.1, RP301.4 (R3), U300.6 (PA4)
/parallel/_WPROT: CN303.28, EMI324.1, RP301.3 (R2), U300.5 (PA3)
A8: U300.38 (RS0); also elsewhere on the board
A9: U300.37 (RS1); also elsewhere on the board
A10: U300.36 (RS2); also elsewhere on the board
A11: U300.35 (RS3); also elsewhere on the board
A12: U302.1; also elsewhere on the board
D0: U300.33 (D0); also elsewhere on the board
D1: U300.32 (D1); also elsewhere on the board
D2: U300.31 (D2); also elsewhere on the board
D3: U300.30 (D3); also elsewhere on the board
D4: U300.29 (D4); also elsewhere on the board
D5: U300.28 (D5); also elsewhere on the board
D6: U300.27 (D6); also elsewhere on the board
D7: U300.26 (D7); also elsewhere on the board
DIR: CN303.18, EMI317.1; also elsewhere on the board
DKWE: U102.8 (DKWE); also elsewhere on the board
E: U300.25 (E); also elsewhere on the board
GND: C203.2, C259.2, C260.2, C261.2, C300.2, C302.2, C303.2, C322.2, C323.2, C607.2, C909.2, C912.2, C916.1, CN300.5, CN301.0 (PAD), CN301.17, CN301.18, CN301.19, CN301.20, CN301.21, CN301.22, CN301.23, CN301.24, CN301.25, CN302.3, CN302.4, CN302.5, CN302.6, CN302.7, CN303.1, CN303.5, CN303.7, CN303.9, CN303.11, CN303.13, CN303.15, CN303.17, CN303.19, CN303.21, CN303.23, CN303.25, CN303.27, CN303.29, CN303.31, CN303.33, EMI300.2, EMI301.2, EMI302.2, EMI303.2, EMI304.2, EMI305.2, EMI306.2, EMI307.2, EMI308.2, EMI309.2, EMI310.2, EMI311.2, EMI312.2, EMI313.2, EMI314.2, EMI315.2, EMI316.2, EMI317.2, EMI318.2, EMI319.2, EMI320.2, EMI321.2, EMI322.2, EMI323.2, EMI324.2, EMI335.2, EMI336.2, EMI337.2, EMI338.2, EMI339.2, EMI340.2, EMI341.2, Q301.1 (E), U203.7 (GND), U300.1 (GND)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; also elsewhere on the board
unnamed: C259.1, C912.1, CN300.4, FB301.1
unnamed: CN301.1, EMI301.3
unnamed: CN301.2, EMI302.3
unnamed: CN301.3, EMI303.3
unnamed: CN301.4, EMI304.3
unnamed: CN301.5, EMI305.3
unnamed: CN301.6, EMI306.3
unnamed: CN301.7, EMI307.3
unnamed: CN301.8, EMI308.3
unnamed: CN301.9, EMI309.3
unnamed: CN301.10, EMI335.3
unnamed: CN301.11, EMI336.3
unnamed: CN301.12, EMI337.3
unnamed: CN301.13, EMI338.3
unnamed: CN301.14, EMI310.3
unnamed: CN301.16, EMI300.3
unnamed: CN302.1, EMI322.3
unnamed: CN302.2, EMI323.3
unnamed: CN302.8, EMI311.3
unnamed: CN302.9, EMI318.1
unnamed: CN302.10, EMI312.3
unnamed: CN302.11, EMI341.3
unnamed: CN302.12, EMI321.1
unnamed: CN302.13, EMI313.3
unnamed: CN302.14, EMI324.3
unnamed: CN302.15, EMI339.3
unnamed: CN302.16, EMI314.3
unnamed: CN302.17, EMI315.3
unnamed: CN302.18, EMI316.3
unnamed: CN302.19, EMI317.3
unnamed: CN302.21, EMI319.1
unnamed: CN302.22, EMI340.3
unnamed: CN302.23, EMI320.1
unnamed: CN303.4, CN303.14, U108.9 (Q), U203.4
unnamed: EMI310.1, R310.1
unnamed: EMI320.3, F3.2
unnamed: EMI321.3, F4.2
unnamed: FB301.2, R914.2
unnamed: FB303.2, RP300.10 (R9), U300.39 (S)
unnamed: J301.1, U203.6
unnamed: Q301.2 (B), R300.1, R309.1
unnamed: R300.2, U108.8 (~Q)
unnamed: R309.2, U102.46 (MTRON), U900.2
unnamed: U102.44 (DKWEB), U203.13
unnamed: U102.45 (DKWDB), U203.10
unnamed: U102.47 (MTRX), U203.2
unnamed: U108.11 (C), U203.5, U900.6
unnamed: U300.23 (_CS), U302.3
OVL: U300.2 (PA0); also elsewhere on the board
PBUSY: EMI336.1, RP300.6 (R5); also elsewhere on the board
PPD0: EMI302.1, U300.10 (PB0); also elsewhere on the board
PPD1: EMI303.1, U300.11 (PB1); also elsewhere on the board
PPD2: EMI304.1, U300.12 (PB2); also elsewhere on the board
PPD3: EMI305.1, U300.13 (PB3); also elsewhere on the board
PPD4: EMI306.1, U300.14 (PB4); also elsewhere on the board
PPD5: EMI307.1, U300.15 (PB5); also elsewhere on the board
PPD6: EMI308.1, U300.16 (PB6); also elsewhere on the board
PPD7: EMI309.1, U300.17 (PB7); also elsewhere on the board
PPOUT: EMI337.1, RP300.7 (R6); also elsewhere on the board
PSEL: EMI338.1, RP300.8 (R7); also elsewhere on the board
PSTROBE: EMI301.1, RP300.2 (R1), U300.18 (_PC); also elsewhere on the board
R_W: U300.22 (_W); also elsewhere on the board
TBASE: J300.2, U300.19 (TICK); also elsewhere on the board
TICK: J300.1, RP300.3 (R2); also elsewhere on the board
_BRST: C909.1, R602.2, U108.10 (~S), U300.34 (_RESET), U303.10, U607.3, U607.5, U607.12; also elsewhere on the board
_BUSRST: U607.11; also elsewhere on the board
_DKWD: U102.9 (_DKWD); also elsewhere on the board
_FIR0: U300.8 (PA6); also elsewhere on the board
_FIR1: U300.9 (PA7); also elsewhere on the board
_INDEX: CN303.8, EMI340.1, RP301.5 (R4); also elsewhere on the board
_INT2: J3.1, U300.21 (_INT); also elsewhere on the board
_KBCLK: C260.1, CN300.3, FB302.1, FB302.2, RP300.9 (R8), U300.40 (C); also elsewhere on the board
_KBRST: R201.2, U102.5 (_KBRESET); also elsewhere on the board
_LED: U300.3 (PA1); also elsewhere on the board
_MTR: U102.7 (_MTR), U108.12 (D); also elsewhere on the board
_OVR: J3.2; also elsewhere on the board
_PACK: EMI335.1, RP300.5 (R4), U300.24 (_F); also elsewhere on the board
_RST: U607.2; also elsewhere on the board
_SEL0: CN303.10, U102.16 (_SEL); also elsewhere on the board
_SEL2: EMI319.3; also elsewhere on the board
_SEL3: EMI318.3; also elsewhere on the board
_SIDE: CN303.32, EMI313.1; also elsewhere on the board
_STEP: CN303.20, EMI316.1; also elsewhere on the board
_VMA: U302.2; also elsewhere on the board
_VSYNC: J300.3; also elsewhere on the board

Notes on the sheet:
EXT FLOPPY
REV 6.2 fixes list C909 as removed but I haven't seen it removed at all on numerous 6.2 boards. so it is kept here
MOD: Breakout _OVR and _INT2 to pin header to avoid needing to clip to CIA and GARY.
PARALLEL

Schematic: denise.kicad_sch

Parts:
C201, C215, C216, C217: 0.22uF; C_Rect_L11.5mm_W2.6mm_P10.00mm_MKT
C205, C206, C915: 0.1uF; C_Rect_L11.5mm_W2.6mm_P10.00mm_MKT
C214, C226: 470uF 16/25v; CP_Radial_D10.0mm_P5.00mm
C913: 47pF; C_Rect_L11.5mm_W2.6mm_P10.00mm_MKT
C914: 100pF; C_Rect_L11.5mm_W2.6mm_P10.00mm_MKT
CN202: DB23M; DSUB-23_Male_Horizontal_P2.77x2.84mm_EdgePinOffset7.70mm_Ho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
CN203: INTERNAL VIDEO SLOT TOP; VIDEOSLOT
CN206: COMPOSITE; RCA
CN207: INTERNAL VIDEO SLOT BOT; VIDEOSLOT
EMI201: Fitted with a double ferrite beads...; EMI_FILTER
EMI206, EMI207, EMI210, EMI211, EMI229: 100pF (Type C 101); EMI_FILTER
EMI208: 100pF (Type F 101); EMI_FILTER
EMI209: 3.8nF (Type F 382); EMI_FILTER
F5: 4A; C_Rect_L11.5mm_W2.0mm_P10.00mm_MKT
FB216, FB217, FB218, FB219, FB220, FB221, FB900, FB901, FB902, FB903: Ferrite_Bead_Small; FERRITE_BEADS_DOUBLE
HY200: HY200VIDIOT; PinSocket_1x22_P2.54mm_Vertical
R203, R211, R216: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R212: 22; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R215: 1; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
RP201, RP203: 47 (isolated, pack); R_Array_SIP8
RP205: 1k; R_Array_SIP6
RP904, RP905, RP906: 4.7k; R_Array_SIP6
U201: DENISE8373; DIP-48_W15.24mm_Socket
U205, U206: 74LS244; DIP-20_W7.62mm_Socket
U303: 74F08; DIP-14_W7.62mm_Socket

Connections:
7M: U201.35 (7M); also elsewhere on the board
+5V_USER: C215.2, EMI211.1, R215.2; also elsewhere on the board
+12V: CN203.10; also elsewhere on the board
+12V_USER: C216.1, F5.1; also elsewhere on the board
-5V: C217.1, CN203.31, EMI209.3; also elsewhere on the board
/denise/COMPVID: CN207.13, EMI208.1, HY200.19 (COMP)
B0: HY200.16 (B0), RP201.1 (R1.1), U206.9 (O0b)
B1: CN207.10, HY200.15 (B1), U206.7 (O1b)
B2: CN207.11, HY200.14 (B2), U206.5 (O2b)
B3: HY200.13 (B3), RP201.3 (R2.1), U206.3 (O3b)
C1: U201.36 (CCK); also elsewhere on the board
DRD0: U201.7 (DRD0); also elsewhere on the board
DRD1: U201.6 (DRD1); also elsewhere on the board
DRD2: U201.5 (DRD2); also elsewhere on the board
DRD3: U201.4 (DRD3); also elsewhere on the board
DRD4: U201.3 (DRD4); also elsewhere on the board
DRD5: U201.2 (DRD5); also elsewhere on the board
DRD6: U201.1 (DRD6); also elsewhere on the board
DRD7: U201.48 (DRD7); also elsewhere on the board
DRD8: U201.47 (DRD8); also elsewhere on the board
DRD9: U201.46 (DRD9); also elsewhere on the board
DRD10: U201.45 (DRD10); also elsewhere on the board
DRD11: U201.44 (DRD11); also elsewhere on the board
DRD12: U201.43 (DRD12); also elsewhere on the board
DRD13: U201.42 (DRD13); also elsewhere on the board
DRD14: U201.41 (DRD14); also elsewhere on the board
DRD15: U201.40 (DRD15); also elsewhere on the board
FLTLEFT: CN203.3; also elsewhere on the board
FLTRIGHT: CN203.4; also elsewhere on the board
G0: CN207.6, HY200.11 (G0), U206.12 (O3a)
G1: CN207.7, HY200.10 (G1), U206.14 (O2a)
G2: CN207.8, HY200.9 (G2), U206.16 (O1a)
G3: HY200.8 (G3), RP201.5 (R3.1), U206.18 (O0a)
GND: C201.2, C205.2, C206.1, C214.2, C215.1, C216.2, C217.2, C226.2, C913.1, C914.2, C915.2, CN202.13, CN202.16, CN202.17, CN202.18, CN202.19, CN202.20, CN203.9, CN203.12, CN203.13, CN203.17, CN203.20, CN203.21, CN203.24, CN203.32, CN206.2 (Ext), CN207.1, CN207.5, CN207.9, CN207.12, CN207.22, CN207.32, EMI201.2, EMI206.2, EMI207.2, EMI208.2, EMI209.2, EMI210.2, EMI211.2, EMI229.2, HY200.1 (GND), HY200.22 (GND), RP205.1 (common), U201.37 (GND), U205.1 (OEa), U205.10 (GND), U205.19 (OEb), U206.1 (OEa), U206.10 (GND), U206.19 (OEb); also elsewhere on the board
GND_AUDIO: CN207.34, CN207.36; also elsewhere on the board
M0H: RP205.5 (R4), U201.9 (M0H); also elsewhere on the board
M0V: RP205.4 (R3), U201.38 (M0V); also elsewhere on the board
M1H: RP205.3 (R2), U201.8 (M1H); also elsewhere on the board
M1V: RP205.2 (R1), U201.39 (M1V); also elsewhere on the board
unnamed: C201.1, EMI229.3, RP904.1 (common), RP905.1 (common), RP906.1 (common), U201.19 (VCC)
unnamed: C205.1, C206.2, C214.1, C226.1, HY200.2 (VCC), HY200.21 (VCC), R215.1, U205.20 (VCC), U206.20 (VCC)
unnamed: C914.1, CN203.14, FB903.2, HY200.18 (CSYNC), U205.12 (O3a)
unnamed: CN202.1, FB216.1
unnamed: CN202.2, FB217.1
unnamed: CN202.3, FB900.1
unnamed: CN202.4, FB901.1
unnamed: CN202.5, FB902.1
unnamed: CN202.6, FB218.1
unnamed: CN202.7, FB219.1
unnamed: CN202.8, FB220.1
unnamed: CN202.9, FB221.1
unnamed: CN202.10, FB903.1
unnamed: CN202.11, EMI206.3
unnamed: CN202.12, EMI207.3
unnamed: CN202.14, CN203.30, RP203.3 (R2.1)
unnamed: CN202.15, EMI201.3
unnamed: CN202.21, EMI209.1
unnamed: CN202.22, EMI210.1
unnamed: CN202.23, EMI211.3
unnamed: CN203.7, FB900.2, HY200.7 (AR)
unnamed: CN203.11, FB901.2, HY200.12 (AG)
unnamed: CN203.15, FB902.2, HY200.17 (AB)
unnamed: CN203.18, U205.16 (O1a)
unnamed: CN203.23, FB218.2, RP201.2 (R1.2)
unnamed: CN203.25, FB219.2, RP201.4 (R2.2)
unnamed: CN203.27, FB220.2, RP201.6 (R3.2)
unnamed: CN203.28, HY200.20 (SYNC)
unnamed: CN203.29, FB221.2, RP201.8 (R4.2)
unnamed: CN203.33, R211.2, U303.2
unnamed: CN206.1 (In), EMI208.3
unnamed: EMI206.1, RP203.5 (R3.1)
unnamed: EMI207.1, RP203.7 (R4.1)
unnamed: EMI210.3, F5.2
unnamed: FB216.2, R216.2, U303.1
unnamed: R212.2, U303.3
unnamed: RP203.4 (R2.2), U205.14 (O2a)
unnamed: RP904.2 (R1), U201.23 (R3), U205.17 (I3b)
unnamed: RP904.3 (R2), U201.22 (R2), U205.15 (I2b)
unnamed: RP904.4 (R3), U201.21 (R1), U205.13 (I1b)
unnamed: RP904.5 (R4), U201.20 (R0), U205.11 (I0b)
unnamed: RP905.2 (R1), U201.27 (B3), U206.17 (I3b)
unnamed: RP905.3 (R2), U201.26 (B2), U206.15 (I2b)
unnamed: RP905.4 (R3), U201.25 (B1), U206.13 (I1b)
unnamed: RP905.5 (R4), U201.24 (B0), U206.11 (I0b)
unnamed: RP906.2 (R1), U201.28 (G0), U206.8 (I3a)
unnamed: RP906.3 (R2), U201.29 (G1), U206.6 (I2a)
unnamed: RP906.4 (R3), U201.30 (G2), U206.4 (I1a)
unnamed: RP906.5 (R4), U201.31 (G3), U206.2 (I0a)
unnamed: U201.18 (BURST), U205.4 (I1a)
unnamed: U201.33 (PIXELSW), U205.6 (I2a)
PBUSY: CN207.18; also elsewhere on the board
PPD0: CN207.23; also elsewhere on the board
PPD1: CN207.24; also elsewhere on the board
PPD2: CN207.25; also elsewhere on the board
PPD3: CN207.26; also elsewhere on the board
PPD4: CN207.27; also elsewhere on the board
PPD5: CN207.28; also elsewhere on the board
PPD6: CN207.29; also elsewhere on the board
PPD7: CN207.30; also elsewhere on the board
PPOUT: CN207.16; also elsewhere on the board
PSEL: CN207.21; also elsewhere on the board
PSTROBE: CN203.36; also elsewhere on the board
R0: CN207.2, HY200.6 (R0), U205.9 (O0b)
R1: CN207.3, HY200.5 (R1), U205.7 (O1b)
R2: CN207.4, HY200.4 (R2), U205.5 (O2b)
R3: HY200.3 (R3), RP201.7 (R4.1), U205.3 (O3b)
RAWLEFT: CN207.33; also elsewhere on the board
RAWRIGHT: CN207.35; also elsewhere on the board
RGA1: U201.17 (RGA1); also elsewhere on the board
RGA2: U201.16 (RGA2); also elsewhere on the board
RGA3: U201.15 (RGA3); also elsewhere on the board
RGA4: U201.14 (RGA4); also elsewhere on the board
RGA5: U201.13 (RGA5); also elsewhere on the board
RGA6: U201.12 (RGA6); also elsewhere on the board
RGA7: U201.11 (RGA7); also elsewhere on the board
RGA8: U201.10 (RGA8); also elsewhere on the board
TBASE: C915.1, CN207.14; also elsewhere on the board
VCDAC: CN207.15; also elsewhere on the board
XCLK: R212.1; also elsewhere on the board
_BHS: U205.18 (O0a); also elsewhere on the board
_C4: C913.2, CN203.19; also elsewhere on the board
_CDAC: U201.34 (/CDAC); also elsewhere on the board
_CSYNC: U201.32 (/CSYNC), U205.8 (I3a); also elsewhere on the board
_HSYNC: CN203.22, R203.2, RP203.6 (R3.2), U205.2 (I0a); also elsewhere on the board
_LED: CN207.31; also elsewhere on the board
_LPEN: CN207.19; also elsewhere on the board
_PACK: CN207.20; also elsewhere on the board
_VC1: CN203.34, EMI201.1; also elsewhere on the board
_VC3: CN207.17; also elsewhere on the board
_VSYNC: CN203.26, RP203.8 (R4.2); also elsewhere on the board
_XCLKEN: CN203.16, FB217.2; also elsewhere on the board

Notes on the sheet:
VIDEO

Schematic: coprocessor slot.kicad_sch

Parts:
C600, C601, C602, C603, C604, C605: 0.1uF; C_Rect_L11.5mm_W2.6mm_P10.00mm_MKT
CN600: CO-PROCESSOR_SLOT; COPRO
RP903, RP908: 1k; R_Array_SIP6
RPF603, RPF604: 3.3k; R_Array_SIP10
U600, U601, U603, U604: 74LS245; DIP-20_W7.62mm_Socket
U602, U605: 74ALS245; DIP-20_W7.62mm_Socket

Connections:
28M: CN600.9; also elsewhere on the board
+12V: CN600.10; also elsewhere on the board
-5V: CN600.8; also elsewhere on the board
A1: CN600.29, U600.8 (A6); also elsewhere on the board
A2: CN600.27, U600.7 (A5); also elsewhere on the board
A3: CN600.26, U600.6 (A4); also elsewhere on the board
A4: CN600.24, U600.5 (A3); also elsewhere on the board
A5: CN600.21, U600.4 (A2); also elsewhere on the board
A6: CN600.23, U600.3 (A1); also elsewhere on the board
A7: CN600.28, U600.2 (A0); also elsewhere on the board
A8: CN600.30, U601.2 (A0); also elsewhere on the board
A9: CN600.32, U601.3 (A1); also elsewhere on the board
A10: CN600.34, U601.4 (A2); also elsewhere on the board
A11: CN600.36, U601.5 (A3); also elsewhere on the board
A12: CN600.38, U601.6 (A4); also elsewhere on the board
A13: CN600.39, U601.7 (A5); also elsewhere on the board
A14: CN600.41, U601.8 (A6); also elsewhere on the board
A15: CN600.43, U601.9 (A7); also elsewhere on the board
A16: CN600.45, U602.2 (A0); also elsewhere on the board
A17: CN600.47, U602.3 (A1); also elsewhere on the board
A18: CN600.52, U602.4 (A2); also elsewhere on the board
A19: CN600.54, U602.5 (A3); also elsewhere on the board
A20: CN600.56, U602.6 (A4); also elsewhere on the board
A21: CN600.58, U602.7 (A5); also elsewhere on the board
A22: CN600.57, U602.8 (A6); also elsewhere on the board
A23: CN600.59, U602.9 (A7); also elsewhere on the board
BA1: U600.12 (B6); also elsewhere on the board
BA2: U600.13 (B5); also elsewhere on the board
BA3: U600.14 (B4); also elsewhere on the board
BA4: U600.15 (B3); also elsewhere on the board
BA5: U600.16 (B2); also elsewhere on the board
BA6: U600.17 (B1); also elsewhere on the board
BA7: U600.18 (B0); also elsewhere on the board
BA8: U601.18 (B0); also elsewhere on the board
BA9: U601.17 (B1); also elsewhere on the board
BA10: U601.16 (B2); also elsewhere on the board
BA11: U601.15 (B3); also elsewhere on the board
BA12: U601.14 (B4); also elsewhere on the board
BA13: U601.13 (B5); also elsewhere on the board
BA14: U601.12 (B6); also elsewhere on the board
BA15: U601.11 (B7); also elsewhere on the board
BA16: U602.18 (B0); also elsewhere on the board
BA17: U602.17 (B1); also elsewhere on the board
BA18: U602.16 (B2); also elsewhere on the board
BA19: U602.15 (B3); also elsewhere on the board
BA20: U602.14 (B4); also elsewhere on the board
BA21: U602.13 (B5); also elsewhere on the board
BA22: U602.12 (B6); also elsewhere on the board
BA23: U602.11 (B7); also elsewhere on the board
BD0: U603.18 (B0); also elsewhere on the board
BD1: U603.17 (B1); also elsewhere on the board
BD2: U603.16 (B2); also elsewhere on the board
BD3: U603.15 (B3); also elsewhere on the board
BD4: U603.14 (B4); also elsewhere on the board
BD5: U603.13 (B5); also elsewhere on the board
BD6: U603.12 (B6); also elsewhere on the board
BD7: U603.11 (B7); also elsewhere on the board
BD8: U604.11 (B7); also elsewhere on the board
BD9: U604.12 (B6); also elsewhere on the board
BD10: U604.13 (B5); also elsewhere on the board
BD11: U604.14 (B4); also elsewhere on the board
BD12: U604.15 (B3); also elsewhere on the board
BD13: U604.16 (B2); also elsewhere on the board
BD14: U604.17 (B1); also elsewhere on the board
BD15: U604.18 (B0); also elsewhere on the board
BFC0: RP908.2 (R1), U605.15 (B3); also elsewhere on the board
BFC1: RP908.3 (R2), U605.16 (B2); also elsewhere on the board
BFC2: RP908.4 (R3), U605.17 (B1); also elsewhere on the board
D0: CN600.75, RPF603.9 (R8), U603.2 (A0); also elsewhere on the board
D1: CN600.77, RPF603.8 (R7), U603.3 (A1); also elsewhere on the board
D2: CN600.79, RPF603.7 (R6), U603.4 (A2); also elsewhere on the board
D3: CN600.81, RPF603.6 (R5), U603.5 (A3); also elsewhere on the board
D4: CN600.83, RPF603.5 (R4), U603.6 (A4); also elsewhere on the board
D5: CN600.86, RPF603.4 (R3), U603.7 (A5); also elsewhere on the board
D6: CN600.84, RPF603.3 (R2), U603.8 (A6); also elsewhere on the board
D7: CN600.82, RPF603.2 (R1), U603.9 (A7); also elsewhere on the board
D8: CN600.80, RPF604.2 (R1), U604.9 (A7); also elsewhere on the board
D9: CN600.78, RPF604.3 (R2), U604.8 (A6); also elsewhere on the board
D10: CN600.76, RPF604.4 (R3), U604.7 (A5); also elsewhere on the board
D11: CN600.71, RPF604.5 (R4), U604.6 (A4); also elsewhere on the board
D12: CN600.69, RPF604.6 (R5), U604.5 (A3); also elsewhere on the board
D13: CN600.67, RPF604.7 (R6), U604.4 (A2); also elsewhere on the board
D14: CN600.65, RPF604.8 (R7), U604.3 (A1); also elsewhere on the board
D15: CN600.63, RPF604.9 (R8), U604.2 (A0); also elsewhere on the board
DMAOUT: U600.1 (A->B), U601.1 (A->B), U602.1 (A->B), U605.1 (A->B); also elsewhere on the board
E: CN600.50; also elsewhere on the board
FC0: CN600.31, U605.5 (A3); also elsewhere on the board
FC1: CN600.33, U605.4 (A2); also elsewhere on the board
FC2: CN600.35, U605.3 (A1); also elsewhere on the board
GND: C600.2, C601.2, C602.2, C603.2, C604.2, C605.1, CN600.1, CN600.2, CN600.3, CN600.4, CN600.12, CN600.13, CN600.25, CN600.37, CN600.49, CN600.61, CN600.73, CN600.85, RPF603.1 (common), RPF604.1 (common), U600.10 (GND), U600.19 (CE), U601.10 (GND), U601.19 (CE), U602.10 (GND), U602.19 (CE), U603.10 (GND), U604.10 (GND), U605.10 (GND), U605.19 (CE); also elsewhere on the board
unnamed: RP908.5 (R4), U605.18 (B0)
unnamed: RP908.6 (R5), U605.2 (A0)
READ: RP903.3 (R2), U605.14 (B4); also elsewhere on the board
R_W: CN600.68, U605.6 (A4); also elsewhere on the board
V7M: CN600.7; also elsewhere on the board
VCDAC: CN600.15; also elsewhere on the board
XRDY: CN600.18; also elsewhere on the board
_AS: CN600.74, U605.9 (A7); also elsewhere on the board
_BAS: RP903.6 (R5), U605.11 (B7); also elsewhere on the board
_BEER: CN600.46; also elsewhere on the board
_BGACK: CN600.62; also elsewhere on the board
_BLDS: RP903.4 (R3), U605.13 (B5); also elsewhere on the board
_BOSS: CN600.20; also elsewhere on the board
_BUDS: RP903.5 (R4), U605.12 (B6); also elsewhere on the board
_CBG: CN600.64; also elsewhere on the board
_CBR: CN600.60; also elsewhere on the board
_COPCFG: CN600.11; also elsewhere on the board
_D2P: RPF603.10 (R9), RPF604.10 (R9), U603.1 (A->B), U604.1 (A->B); also elsewhere on the board
_DBOE: U603.19 (CE), U604.19 (CE); also elsewhere on the board
_DTACK: CN600.66; also elsewhere on the board
_HLT: CN600.55; also elsewhere on the board
_INT2: CN600.19; also elsewhere on the board
_INT6: CN600.22; also elsewhere on the board
_IPL0: CN600.40; also elsewhere on the board
_IPL1: CN600.42; also elsewhere on the board
_IPL2: CN600.44; also elsewhere on the board
_LDS: CN600.70, U605.7 (A5); also elsewhere on the board
_OVR: CN600.17; also elsewhere on the board
_RST: CN600.53; also elsewhere on the board
_UDS: CN600.72, U605.8 (A6); also elsewhere on the board
_VC1: CN600.16; also elsewhere on the board
_VC3: CN600.14; also elsewhere on the board
_VMA: CN600.51; also elsewhere on the board
_VPA: CN600.48; also elsewhere on the board

Notes on the sheet:
REV 6.2 fixes: RP900 and RP901, 3.3k both, connected to D[0..15] were removed And instead connected directly to U603 and U604

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
Board: 2 copper layers, 558 parts (0 on the bottom side), 731 nets, no tracks yet.
